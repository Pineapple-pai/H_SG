# Keil uVision project SG_CHASSIS_C_2024_11_5.uvprojx, settings and files
target SG_CHASSIS_C_2024_11_5 (6140001::V6.14.1::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: SG_CHASSIS_C_2024_11_5 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx ARM_MATH_CM4,__FPU_PRESENT,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../../../../AppData/Local/Arm/Packs/ARM/CMSIS-DSP/1.15.0/Include;../Middlewares/ST/ARM/DSP/Inc;./User/APP;./User/BSP;./User/Algorithm;./User/HAL;./User/Task
  asm include: ../Core/Inc;../Middlewares/ST/ARM/DSP/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group HAL
    ./User/HAL/CAN/impl/: can_bus_impl.cpp can_device_impl.cpp
    ./User/HAL/CAN/interface/: can_bus.cpp can_device.cpp
    ./User/HAL/CAN/: can_hal.hpp
    ./User/HAL/UART/impl/: uart_bus_impl.cpp uart_device_impl.cpp
    ./User/HAL/UART/interface/: uart_bus.cpp uart_device.hpp
    ./User/HAL/UART/: uart_hal.hpp
    ./User/HAL/LOGGER/: logger.cpp rtt_debug_service.cpp
    ./User/HAL/LOGGER/SEGGER/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group BSP
    ./User/BSP/: Init.cpp Bsp_Can.cpp BSP_Motor.cpp state_watch.cpp
    ./User/BSP/Power/: PM01.hpp
    ./User/BSP/SuperCap/: SuperCap.hpp
    ./User/BSP/Motor/Dji/: DjiMotor.hpp
    ./User/BSP/Motor/: MotorBase.hpp
    ./User/BSP/Motor/Lk/: Lk_motor.hpp
    ./User/BSP/Remote/: Dbus.cpp
    ./User/BSP/Common/StateWatch/: buzzer_manager.cpp
  group App
    ./User/APP/: PowerMeter.cpp Variable.cpp State.cpp Tools.cpp Buzzer.cpp LED.cpp
    ./User/APP/Referee/: RM_RefereeSystem.cpp RM_RefereeSystemCRC.cpp
    ./User/APP/UI/Static/: darw_static.cpp
    ./User/APP/UI/Dynamic/: darw_dynamic.cpp
    ./User/APP/Remote/: Mode.hpp
  group Algorithm
    ./User/Algorithm/: PID.cpp Wheel.cpp Matrix.hpp RLS.hpp Ude.hpp alg_slope.cpp alg_slope.h drv_math.cpp drv_math.h
    ./User/Algorithm/ChassisCalculation/: CalculationBase.hpp StringWheel.hpp
  group Task
    ./User/Task/: CallBack.cpp ChassisTask.cpp CommunicationTask.cpp RefeeTask.cpp PowerTask.cpp EvenTask.cpp
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 6.1.0
